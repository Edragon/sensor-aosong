# Keil uVision project uart_int.uvprojx, settings and files
target uart_int_Release (ARM-ADS)
  device: HC32F003C4PA HDSC
  pack: HDSC.HC32F003.1.0.1
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uart_int +hex
  c flags: Optim=1
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group common
    ./: startup_hc32f003.s
    ../../../../mcu/common/: system_hc32f003.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: interrupts_hc32f003.c clk.c uart.c bt.c gpio.c ddl.c wdt.c
    ../source/: sensor3123.c pcf8562.c
software components: CMSIS:CORE 5.1.1
